# Keil uVision project SVPE18MII.uvprojx, settings and files
target SVPE18MII (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SVPE18MII +hex
  c flags: Optimize=9
  c define: IN_KEIL
  link misc: REMOVEUNUSED
  group StartUp
    ./Src/: main.c STARTUP.A51 Conf_tny.A51
  group STCLib
    ./Src/STCLib/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C spi.c
  group Board
    ./Src/Board/: BoardSVPE18MII.c LED.c ChipSE0164.c ChipIP101G.c
  group Comm
    ./Src/communication/: command.c console.c dcc.c
  group Business
    ./Src/Business/: Device.c E1Port.c ConfigData.c EthPort.c VCG.c ConfigModule.c
  group Alarm
    ./Src/Alarm/: AlarmModule.c AlmSrcE1.c AlmSrcEth.c AlmSrcVCG.c
